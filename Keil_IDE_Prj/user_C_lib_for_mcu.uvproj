# Keil uVision project user_C_lib_for_mcu.uvproj, settings and files
target cortex-M3 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: my_soft (library)
  c flags: Optim=1
  group src
    ../: big_endian_to_uint.c
